*  CMOS inverter
*tranfer_char/transient response/power for varing W of nmos

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt

m0 out in vd 5 CMOSP l=1u w=.6u  *LOAD
m1 out in 0 0 CMOSN l=1u w=.2u	 *Driver

*sources
vdd vd 0 dc 5
vin in 0 dc 5 pulse(5 0 .01m .2m .2m .5m 1m)

*.dc vin 0 5 .01

*varing W/L ratio

.control
foreach wid .6u 2u 10u
alter m1 w = $wid
tran .001m 1m
run
end
.endc

*plotting the output for various w of load

.control
foreach iter 1 2 3
setplot tran$iter
*setplot dc$iter
end
.endc

*ploting graph for transfer char

.control
let x_500_nano= tran1.out
let y_2u= tran2.out
let z_6u= tran3.out
plot x_500_nano,y_2u,z_6u
end
.endc

*ploting graph for power

*.control
*let x= -tran1.vdd#branch
*let y= -tran2.vdd#branch
*let z= -tran3.vdd#branch
*plot x*vd, y*vd, z*vd
*end
*.endc
