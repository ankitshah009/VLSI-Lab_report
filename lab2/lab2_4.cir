* nmos inverter resistiv load

*Effect on transfer fun due to varing R

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt
r1 vd out 1k
m1 out in 0 0 CMOSN l=1u w=1u

*sources
vdd vd 0 dc 3.3
vin in 0 dc 3.3

.dc vin 0 6 .01

*varing R resistant

.control
foreach resi 3k 10k 100k
alter r1 = $resi
run
end
.endc

*plotting the output for various  resistant
.control
foreach iter 1 2 3
setplot dc$iter
plot out
end
.endc
