*nmos characteristics

*include model files

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level1.txt

*netlist
m1 drain gate 0 0 RITSUBN1 l=3u w=0.5u

*define the sources
vdd drain 0 dc 5
vgg gate 0 dc 5
.dc vdd 0 5 0.1 vgg 0 5 1

*Computing the response for various width
.control
foreach wid 1e-6 3e-6 5e-6
alter m1 w = $wid
run
end
.endc

*plotting the output for various width
.control
foreach iter 1 2 3
setplot dc$iter
plot -vdd#branch
end
.endc
