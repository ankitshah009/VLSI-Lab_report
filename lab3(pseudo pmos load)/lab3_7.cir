*  inverter with NMOS load
*tranfer fun/transient response for varing l of load pmos

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt

m0 vd 0 out 5 CMOSP l=1u w=1u  *LOAD
m1 out in 0 0 CMOSN l=1u w=1u	 *Driver

*sources
vdd vd 0 dc 5
vin in 0 dc 5
*pulse(0 5 0 0 0 .5m 1m)

.dc vin 0 5 .01

*varing W/L ratio
.control
foreach len 1u 2u 5u
alter m0 l = $len
run
*tran 0.01m 2m
end
.endc

*plotting the output for various w of load
.control
foreach iter 1 2 3
setplot dc$iter
end
.endc

.control
let x= dc1.out
let y= dc2.out
let z= dc3.out
plot x,y,z
end
.endc
