* nmos inverter resistiv load
.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt
r1 vd out 0.1k
m1 out in 0 0 CMOSN l=1u w=1u
c1 out 0 1n

*sources
vdd vd 0 dc 3.3
vin in 0 dc 3.3 pulse(5 0 .1n .5m .5m 3m 10m)
*pulse(0 3.3 1n .1n .1n 2n 4n)

*.dc vin 0 6 .01

* for transfer fun pic
*.control
*run
*plot out
*.endc

*varing W/L ratio
*.control
*foreach wid .12u .25u 2.5u
*alter m1 w = $wid
*tran .01n 10n
*run
*end
*.endc

*varing R resistant 1k 10k
*.control
*foreach resi 3k 10k 100k
*alter r1 = $resi
*tran .01n 10n
*run
*end
*.endc

*varing capacitance
.control
foreach cap 1p 1n 1u
alter c1 = $cap
tran .01m 20m
run
end
.endc

*plotting the output for various w/L (or resistant)
.control
foreach iter 1 2 3
setplot tran$iter
*setplot dc$iter
plot out
end
.endc
