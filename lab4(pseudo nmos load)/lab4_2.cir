*  inverter with pseudo NMOS load
*transient response only

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt

m2 vd vd out 0 cmosn l=1u w=.1u
m1 out in 0 0 cmosn l=1u w=5u

*sources
vdd vd 0 dc 5
vin in 0 dc 5 pulse(0 5 0 0 0 2u 4u)

*for transfer fun pic
.control
tran .01u 10u
run
plot out,in
.endc
