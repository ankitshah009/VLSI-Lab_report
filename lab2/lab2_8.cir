* nmos inverter resistiv load

*effect on transient responce due to varing load capacitance

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt
r1 vd out 0.1k
m1 out in 0 0 CMOSN l=1u w=1u
c1 out 0 1n

*sources
vdd vd 0 dc 3.3
vin in 0 dc 3.3 pulse(0 3.3 1n .1n .1n 2n 4n)

*varing capacitance

.control
foreach cap 1p 1n 1u
alter c1 = $cap
tran .01n 10n
run
end
.endc

*plotting the output for various cap

.control
foreach iter 1 2 3
setplot tran$iter
plot out
end
.endc
