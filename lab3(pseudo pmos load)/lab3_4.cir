*  inverter with NMOS load
*transient responce for varing W of driver nmos

.include /home/krunal/VLSI_LAB/VINAY/t14y_tsmc_025_level3.txt

m0 vd 0 out 5 CMOSP l=2u w=1u  *LOAD
m1 out in 0 0 CMOSN l=2u w=1u	 *Driver

*sources
vdd vd 0 dc 5
vin in 0 dc 5 pulse(0 5 10n 10u 10u 1m 2m)

*.dc vin 0 5 .01

*varing W/L ratio
.control
foreach wid .5u .8u 1.5u
alter m1 w = $wid
tran 0.01m 5m
end
.endc

*plotting the output for various w of load
.control
foreach iter 1 2 3
setplot tran$iter
end
.endc

.control
let x= tran1.out
let y= tran2.out
let z= tran3.out
plot x,y,z
end
.endc
